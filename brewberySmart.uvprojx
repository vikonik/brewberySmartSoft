# Keil uVision project brewberySmart.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: K1986VE1xI Milandr
  pack: Milandr.MDR32FxQI.1.3.2
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: HeatINtelekt
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\user;.\user\Display;.\user\DS18B20;.\user\Test;.\user\GUI;.\user\Button;.\user\Recept;.\user\W25Q64
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group user
    ./user/: main.c allDefenition.h delay.c delay.h interrupts.c interrupts.h I2C_soft.c I2C_soft.h MDR32_inout.c MDR32_inout.h hc595.h hc595.c port.c port.h brew_control.c brew_control.h HAL.c HAL.h functional.c functional.h pid.c pid.h MDR32_uart.c MDR32_uart.h tempSensor.c tempSensor.h
  group Display
    ./user/Display/: c64enh_font.h font.h grapf.c graph.h microsoftSansSerif_8ptFont.c microsoftSansSerif_8ptFont.h microsoftSansSerif22pts_digit.c microsoftSansSerif22pts_digit.h seg7_12x21dig_font.h ST7567_FB.c ST7567_FB.h
  group DS18B20
    ./user/DS18B20/: ds18b20.c ds18b20.h onewire.c onewire.h
  group test
    ./user/Test/: anyTest.c anyTest.h
  group GUI
    ./user/GUI/: mainPage.c mainPage.h menu.c menu.h mainfest.c manifest.h menuRecept.c menuRecept.h menuClearing.c menuClearing.h menuManualControl.c menuManualControl.h
  group Buton
    ./user/Button/: MPR121.c MPR121.h button.c button.h
  group Recept
    ./user/Recept/: recept.c recept.h state_machine.c state_machine.h recipe_manager.c recipe_manager.h
  group W25Q64
    ./user/W25Q64/: w25qxx.c w25qxx.h w25qxxConf.h w25qxx_spi.c w25qxx_spi.h
software components: Device:Startup 2.2.0i, Drivers:BKP 2.2.0i, Drivers:EEPROM 2.2.0i, Drivers:PORT 2.2.0i, Drivers:RST_CLK 2.2.0i, Drivers:SSP 2.2.0i, Drivers:TIMER 2.2.0i, Drivers:UART 2.2.0i, Drivers:UTILS 1.2.0i
